# Keil uVision project RTC.uvprojx, settings and files
target RTC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\RTC;..\USMART;..\HARDWARE\DHT11;..\HARDWARE\DEVICE;..\SYSTEM\usartOneNet;..\NET\onenet\inc;..\NET\MQTT;..\NET\device\inc;..\NET\NtpEsp8266;..\HARDWARE\SMOG;..\HARDWARE\ADC;..\HARDWARE\bh1750;..\HARDWARE\OLED;..\HARDWARE\PM2.5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/DEVICE/: Device.c
    ../HARDWARE/SMOG/: smog.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/bh1750/: bh1750.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/PM2.5/: PM2.5.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usartOneNet/: usartOneNet.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_i2c.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group NET
    ../NET/onenet/src/: onenet.c
    ../NET/MQTT/: MqttKit.c
    ../NET/device/src/: esp8266.c
    ../NET/NtpEsp8266/: gettime.c
